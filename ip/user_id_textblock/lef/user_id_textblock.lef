VERSION 5.7 ;
  NOWIREEXTENSIONATPIN ON ;
  DIVIDERCHAR "/" ;
  BUSBITCHARS "[]" ;
MACRO user_id_textblock
  CLASS BLOCK ;
  FOREIGN user_id_textblock ;
  ORIGIN 3.280 0.000 ;
  SIZE 173.750 BY 51.720 ;
  OBS
      LAYER met5 ;
        RECT 0.0 0.0 173.750 51.720 ;
  END
END user_id_textblock
END LIBRARY

